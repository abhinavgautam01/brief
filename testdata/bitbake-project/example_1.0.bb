SUMMARY = "Example recipe"
